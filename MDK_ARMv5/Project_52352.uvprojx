# Keil uVision project Project_52352.uvprojx, settings and files
target HT32 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.44
  cpu: IROM(0x00000000-0x0001FDFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities;..\HardWare;..\StartUp;..\Config;..\Math
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ALL_DATA.h Init.c control.c
    ../HardWare/: oled.c led.c wt_imu.c
    ../Config/: delay.c pwm.c time.c uart.c
    ../StartUp/: ht32f5xxxx_01_it.c
  group Config
    ../: ht32_board_config.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
    ../StartUp/: ht32f5xxxx_01_usbdconf.h ht32f5xxxx_conf.h
  group CMSIS
    ../StartUp/: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
  group Doc
    ../: readme.txt
  group Math
    ../Math/: filter.c kalman.c myMath.c pid.c
